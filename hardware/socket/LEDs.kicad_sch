File: hardware/socket/LEDs.kicad_sch (KiCad schematic)
At the start: 20 parts

Commit message: Split into socket and plug
Other:
- title: V2 connect -> V2 connect-socket
